FILESEXTRAPATHS:prepend := "${THISDIR}/foot:"

SRC_URI += "file://0002-fix-switch-case-error.patch"
